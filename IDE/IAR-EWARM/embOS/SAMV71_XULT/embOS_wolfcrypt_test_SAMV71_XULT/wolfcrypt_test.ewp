# IAR project wolfcrypt_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG=1; __SAMV71Q21__; WOLFSSL_USER_SETTINGS; WOLFSSL_EMBOS; ECC_SHAMIR
  ICCARM.CCIncludePath2: C:\embos-trial\Start\Inc; C:\embos-trial\Start\BoardSupport\Atmel\SAMV71_XPlainedUltra\DeviceSupport; C:\embos-trial\Start\BoardSupport\Atmel\SAMV71_XPlainedUltra\Setup; C:\Users\boz_windows\Desktop\wolfssl; C:\Users\boz_windows\Desktop\wolfssl\IDE\IAR-EWARM\embOS\SAMV71_XULT\embOS_SAMV71_XULT_user_settings
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wolfcrypt_test.srec
  ILINK.IlinkOutputFile: wolfcrypt_test.out
  ILINK.IlinkIcfFile: C:\Users\boz_windows\Desktop\wolfssl\IDE\IAR-EWARM\embOS\SAMV71_XULT\embOS_SAMV71_XULT_Linker_Script\samv71q21_wolfssl.icf
  ILINK.IlinkAdditionalLibs: C:\Users\boz_windows\Desktop\wolfssl\IDE\IAR-EWARM\embOS\SAMV71_XULT\embOS_wolfcrypt_lib_SAMV71_XULT\Debug\Bin\wolfcrypt_lib.a; C:\embos-trial\Start\Lib\os7m_tlv_dp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: runWolfcryptTests.c
  group Device_Support
    ../../../../../../../../../embos-trial/Start/BoardSupport/Atmel/SAMV71_XPlainedUltra/DeviceSupport/: startup_sam.c system_sam.c
  group Setup
    ../../../../../../../../../embos-trial/Start/BoardSupport/Atmel/SAMV71_XPlainedUltra/Setup/: BSP.c HardFaultHandler.S JLINKMEM_Process.c OS_Error.c RTOSInit_SAMV71_CMSIS.c SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group wolfcrypt_test
    ../../../../../wolfcrypt/test/: test.c
